# Keil uVision project Project.uvprojx, settings and files
target STM324xG_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324xG_EVAL
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM324xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM324xG_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/User
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c io_config.c io_pin.c io_read_write.c general_purpose_func.c usart_2.c usart_3.c can.c motor.c flash.c
  group Example/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval.c stm324xg_eval_io.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_adc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal.c stm32f4xx_hal_usart.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
software components: CMSIS:CORE 5.0.0
